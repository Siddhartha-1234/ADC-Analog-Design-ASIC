** sch_path: tb_inverter.sch
**.subckt tb_inverter
x1 net1 net2 net3 GND inverter
V1 VDD GND 3
V2 IN GND 3
**.ends
.GLOBAL GND
.end
