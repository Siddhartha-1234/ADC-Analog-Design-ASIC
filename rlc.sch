** sch_path: rlc.sch
**.subckt rlc
C1 B C 50nF m=1
L1 A B 10mH m=1
R1 A 0 1k m=1
E1 C 0 VOL=' '3*cos(time*time*time*1e11)' '
**.ends
.end
