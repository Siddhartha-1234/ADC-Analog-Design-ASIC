v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/ttuser/Documents/ADCAnalogDesign/analogSwitch.sym} 30 -100 0 0 {name=x1}
C {/home/ttuser/Documents/ADCAnalogDesign/onehot2mux.sym} 40 60 0 0 {name=x2}
C {/home/ttuser/Documents/ADCAnalogDesign/comparator.sym} 510 -30 0 0 {name=x3}
